# The UNO Q's eMMC layout (files/partitions.conf) instead of the UFS one.
FILESEXTRAPATHS:prepend:arduino-uno-q-wendyos := "${THISDIR}/files:"
