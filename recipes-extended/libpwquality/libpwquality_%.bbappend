# The Python bindings are unused and would bring python3 into every image.
PACKAGECONFIG:remove:class-target = "python3"
