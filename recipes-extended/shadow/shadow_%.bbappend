require shadow-usg-notice.inc
