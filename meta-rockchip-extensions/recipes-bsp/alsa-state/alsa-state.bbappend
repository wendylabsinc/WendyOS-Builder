# The ES8388 resets with capture at -96 dB and its PGA on the jack input; ship
# usable defaults: onboard microphone at +24 dB, capture and output at 0 dB.
FILESEXTRAPATHS:prepend:orangepi-5-pro-wendyos := "${THISDIR}/${BPN}:"
PACKAGE_ARCH:orangepi-5-pro-wendyos = "${MACHINE_ARCH}"
